# Keil uVision project Den_Giao_Thong.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Den_FIX_Lan_hai +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.C
    ./delay/: delay.c
